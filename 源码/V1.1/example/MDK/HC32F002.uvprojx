# Keil uVision project HC32F002.uvprojx, settings and files
target HC32F002_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HC32F002C4PZ HDSC
  pack: HDSC.HC32F002.1.0.0
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DC721H_V10 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\common;..\User;..\..\driver\inc;..\..\driver\src;..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f002.s
    ../../common/: system_hc32f002.c base_types.h HC32F002.h board_stkhc32f002.h interrupts_hc32f002.c interrupts_hc32f002.h system_hc32f002.h ddl_device.h
  group Driver
    ../../driver/src/: adc.c atim3.c btim.c ctrim.c ddl.c flash.c gpio.c gtim.c i2c.c iwdt.c lpm.c lpuart.c lvd.c spi.c sysctrl.c wwdt.c
    ../../driver/inc/: adc.h atim3.h btim.h ctrim.h ddl.h flash.h gpio.h gtim.h i2c.h iwdt.h lpm.h lpuart.h lvd.h spi.h sysctrl.h wwdt.h
  group User
    ../User/: User_System.c User_Timer.c User_Iwdt.c User_CRC.c User_Flash.c User_Button.c User_RF433.c User_BeepLed.c User_Light.c User_MOT.c main.c
  group Include
    ../Include/: User_System.h User_Timer.h User_Iwdt.h User_Flash.h User_CRC.h User_Button.h User_RF433.h User_BeepLed.h User_Light.h User_MOT.h User_Include.h
software components: CMSIS:CORE 5.1.2
